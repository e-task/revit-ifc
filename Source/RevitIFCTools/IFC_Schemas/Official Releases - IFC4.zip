Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: beam_curved_revolved-solid_design-handover-view.ifc
Time: 2014-06-09T14:06:08
Author: Jon Mirtschin
Organization: Geometry Gym
Written by: ggGrasshopperIFC
Made in: ggGrasshopperIFC
Comment: use the correct model view definition for the IFC4 design handover view
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: IfcOwnerHistory is in scope of the IFC4 reference view required for project
Comment: optionally define recurring instances, such as zero point and main directions
Comment: those can be referenced multiple times reducing file sizes
Comment: set the representation context for 3D body, and 2D axis representation
Comment: north direction is set to positive y-axis, no geo-spatial coordinates are provided
Comment: set the default units - and the units used for geometric representations
Comment: defines the default building (as required as the minimum spatial element)
Comment: set the context of the IFC4 exchange file
Comment: defines the beam beam type with the material profile set as a joint profile definition
Comment: defines the beam as a standard case element with revolved solid geometry
Comment: the profile set usage indicated the cardinal point
Comment: defines the beam axis representation
Comment: defines the beam solid representation as a revolved area solid
Comment: defines the beam profile being an I-shape profile IPE600

# IfcProject, Grasshopper Project
LongName: Grasshopper Project

# IfcBuilding, Grasshopper Building
Description: GH Building; LongName: GH Building

# IfcBeam: IPE600
In: Grasshopper Building
Type - PredefinedType: BEAM; Material: S355JR

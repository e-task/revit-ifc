Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned], Comment [manual creation of example file]
File name: standard_case_element_beam.ifc
Time: 2011-11-07T18:00:00
Author: Thomas Liebich
Organization: buildingSMART International
Written by: IFC text editor
Made in: IFC text editor
Authorization: reference file created for the IFC4 specification
Comment: NOTE a valid model view name has to be asserted, replacing 'notYetAssigned'
Comment: NOTE standard header information according to ISO 10303-21
Comment: NOTE schema name to be replaced with 'IFC4' after the final release
Comment: enhanced definitions intruduced in IFC2x4
Comment: assignment of material and profile to the beam type
Comment: end of enhanced definitions
Comment: beam A-1 - beam axis along global x axis
Comment: cardinal point = 1 - bottom left
Comment: enhanced definitions intruduced in IFC2x4 - IfcBeamStandardCase
Comment: set local placement so that the z-axis is co-linear to the beam axis
Comment: the y-axis (cross product of x & z axis) is up direction of profile
Comment: local z-axis co-linear to beam axis
Comment: local x-axis
Comment: extrusion body is placed with no rotation inside local placement
Comment: extrusion position z = default = (0.,0.,1.),x = default = (1.,0.,0.)
Comment: translation provides the cardinal point offset
Comment: defines cardinal point 1
Comment: assignment of material and cardinal point to the beam occurrence
Comment: beam A-2 - beam axis along global x axis
Comment: cardinal point = 2 - bottom center
Comment: defines cardinal point 2
Comment: beam A-3 - beam axis along global x axis
Comment: cardinal point = 3 - bottom right
Comment: defines cardinal point 3
Comment: beam A-4 - beam axis along global x axis
Comment: defines cardinal point 4
Comment: beam A-5 - beam axis along global x axis
Comment: cardinal point = 5 - mid-depth center
Comment: defines cardinal point 5
Comment: beam A-6 - beam axis along global x axis
Comment: cardinal point = 6 - mid-depth right
Comment: defines cardinal point 6
Comment: beam A-7 - beam axis along global x axis
Comment: cardinal point = 7 - top left
Comment: defines cardinal point 7
Comment: beam A-8 - beam axis along global x axis
Comment: cardinal point = 8 - top center
Comment: beam A-9 - beam axis along global x axis
Comment: cardinal point = 9 - top right
Comment: defines cardinal point 9
Comment: beam B-1 - beam axis along global x axis
Comment: beam B-2 - beam axis along global x axis
Comment: beam B-3 - beam axis along global x axis
Comment: beam B-4 - beam axis along global x axis
Comment: cardinal point = 4 - mid-depth left
Comment: beam B-5 - beam axis along global x axis
Comment: cardinal point = 5 - mid-depth centre
Comment: beam B-6 - beam axis along global x axis
Comment: beam B-7 - beam axis along global x axis
Comment: defines cardinal point 7 -
Comment: beam B-8 - beam axis along global x axis
Comment: cardinal point = 3 - top center
Comment: defines cardinal point 8
Comment: beam B-9 - beam axis along global x axis
Comment: defines cardinal point 9 -
Comment: general entities required for all IFC data sets, defining the context for the exchange

# IfcBeam: 1/2IPE300 (9)
In: Building
Type - Description: Beam type; PredefinedType: BEAM; Material: S275J2
Description: 1/2IPE300
Name
B-1
B-2
B-3
B-4
B-5
B-6
B-7
B-8
B-9

# IfcBeam: IPE220 (9)
In: Building
Type - Description: Beam type; PredefinedType: BEAM; Material: S275J2
Description: IPE220
Name
A-1
A-2
A-3
A-4
A-5
A-6
A-7
A-8
A-9

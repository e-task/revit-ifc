Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1]
Time: 2016-02-04T08:47:55
Author: Jon
Organization: Unknown
Written by: GeomGymIFC by Geometry Gym Pty Ltd
Made in: Unknown Application
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: general entities required for all IFC data sets, defining the context for the exchange
Comment: defines the default building (as required as the minimum spatial element)

# IfcBeam: CHS219.1x6.3
In: IfcBuilding
Type - PredefinedType: BEAM; Material: S355JR

# IfcBeam: IPE200
In: IfcBuilding
Type - PredefinedType: JOIST; Material: S355JR

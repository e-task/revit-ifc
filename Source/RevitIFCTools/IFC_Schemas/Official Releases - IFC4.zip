Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [notYetAssigned]
File name: polygonal-faceset-cube.ifc
Time: 2016-05-26T17:38:29
Author: jonm
Organization: Geometry Gym
Written by: GeomGymIFC by Geometry Gym Pty Ltd
Made in: ggRhinoIFC - Grasshopper3d Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization
Comment: polygonal face set geometry representation
Comment: assigned as shape representation to a proxy
Comment: definition of the minimal building structure, units, owner history

# IfcBuilding, Grasshopper Building
Description: GH Building; LongName: GH Building; ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
